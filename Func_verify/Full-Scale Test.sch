** sch_path: Func_verify/Full-Scale Test.sch
**.subckt Full-Scale Test
x1 VDD CDAC_out_p CDAC_out_n Out_comp CLK_sar CLKB_sar GND adc_comparator
x2 EOC CLK_sar Out_comp VDD GND CLK_samp d9 d4 d10 d5 d6 d3 d2 d1 d0 d7 d8 d11 SAR_Logic_TSPC
x5 Final_Out GND Vref_n reg_d7 reg_d3 reg_d11 reg_d10 reg_d6 reg_d2 reg_d5 reg_d1 reg_d9 reg_d0
+ reg_d4 reg_d8 DAC_test_ideal
VDD VDD GND 1.8
Vcm Vcm GND 0.9
Vref_n Vref_n GND 0.3
Vref_p Vref_p GND 1.5
x8 VDD d8 d5 d11 d2 reg_d11 reg_d8 reg_d5 reg_d2 EOC d7 d1 d10 d4 reg_d1 reg_d4 reg_d7 reg_d10 d0 d3
+ d6 d9 reg_d0 reg_d3 reg_d6 reg_d9 GND SAR_Register_v2
x3 Vref_n Vin_n d0 d1 d2 VDD d3 GND d4 CDAC_out_p Vcm d5 CLK_samp d6 CLKB_samp d7 CDAC_out_n d8 d9
+ d10 d11 Vin_p Vref_p CAP_MIM_DAC_SplitCharge
Vin_n Vin_n GND 0.3
Vin_p Vin_p GND 1.5
x7 VDD VCLOCK net1 CLKB_samp CLK_samp CLKB_sar EOC CLK_sar GND Pulse_Generator
VCLOCK VCLOCK GND pulse (0 1.8 0ns 0.1ns 0.1ns 100ns 200ns)
**** begin user architecture code
.lib $::SKYWATER_MODELS/sky130.lib.spice tt


*.param Cu=4.166f
.param gain=2/3
.control
option savecurrents=no
save v(out_comp) v(d11) v(d10) v(d9) v(d8) v(d7) v(d6) v(d5) v(d4) v(d3) v(d2) v(d1) v(d0)
+ v(reg_d11) v(reg_d10) v(reg_d9) v(reg_d8) v(reg_d7) v(reg_d6) v(reg_d5) v(reg_d4) v(reg_d3) v(reg_d2)
+ v(reg_d1) v(reg_d0) V(vin_n) V(vin_p) v(cdac_out_p) v(cdac_out_n) v(eoc) V(final_out) V(clk_samp) v(clk_sar)
+ v(x3.in_n_sampled) v(x3.in_p_sampled)
*tran 0.1n 409.9u 0.3u
tran 0.05n 1u 0.3u
write sar_adc_full_scale_test.raw
.endc


**** end user architecture code
**.ends

* expanding   symbol:  adc_comparator.sym # of pins=7
** sym_path: Func_verify/adc_comparator.sym
** sch_path: Func_verify/adc_comparator.sch
.subckt adc_comparator VDD In_Comp_P In_Comp_N Out_Comp CLK CLKB GND
*.ipin VDD
*.ipin GND
*.ipin In_Comp_P
*.ipin In_Comp_N
*.ipin CLK
*.ipin CLKB
*.opin Out_Comp
XM1 O_n CLK VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 O_p CLK VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3 net2 Out_Comp VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=10 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM4 net3 net4 VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=10 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM5 net4 O_n net2 VDD sky130_fd_pr__pfet_01v8 L=0.15 W=10 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM6 Out_Comp O_p net3 VDD sky130_fd_pr__pfet_01v8 L=0.15 W=10 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM7 O_n In_Comp_P net1 GND sky130_fd_pr__nfet_01v8 L=0.15 W=6.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM8 O_p In_Comp_N net1 GND sky130_fd_pr__nfet_01v8 L=0.15 W=6.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM9 net1 CLK GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM10 net4 CLKB GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM11 net4 Out_Comp GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM12 Out_Comp net4 GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM13 Out_Comp CLKB GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  SAR_Logic_TSPC.sym # of pins=18
** sym_path: Func_verify/SAR_Logic_TSPC.sym
** sch_path: Func_verify/SAR_Logic_TSPC.sch
.subckt SAR_Logic_TSPC EOC CLK COMP VDD VSS Reset D9 D4 D10 D5 D6 D3 D2 D1 D0 D7 D8 D11
*.ipin CLK
*.ipin VDD
*.ipin VSS
*.ipin COMP
*.opin D11
*.opin D10
*.opin D9
*.opin D8
*.opin D7
*.opin D6
*.opin D5
*.opin D4
*.opin D3
*.opin D2
*.opin D1
*.opin D0
*.ipin Reset
*.opin EOC
x1 VDD VSS net2 D10 Reset COMP D11 FFD_TSPC
x2 VDD VSS net3 D9 Reset COMP D10 FFD_TSPC
x3 VDD VSS net4 D8 Reset COMP D9 FFD_TSPC
x4 VDD VSS net5 D7 Reset COMP D8 FFD_TSPC
x5 VDD VSS net6 D6 Reset COMP D7 FFD_TSPC
x6 VDD VSS net7 D5 Reset COMP D6 FFD_TSPC
x7 VDD VSS net8 D4 Reset COMP D5 FFD_TSPC
x8 VDD VSS net9 D3 Reset COMP D4 FFD_TSPC
x9 VDD VSS net10 D2 Reset COMP D3 FFD_TSPC
x10 VDD VSS net11 D1 Reset COMP D2 FFD_TSPC
x11 VDD VSS net12 D0 Reset COMP D1 FFD_TSPC
x12 VDD VSS net14 net13 Reset COMP D0 FFD_TSPC
x13 VDD VSS EOC VSS Reset VSS net13 FFD_TSPC
x14 VDD VSS Reset CLK VSS VSS net1 FFD_TSPC
x15 VDD VSS VSS CLK Reset net1 net2 FFD_TSPC
x16 VDD VSS VSS CLK Reset net2 net3 FFD_TSPC
x17 VDD VSS VSS CLK Reset net3 net4 FFD_TSPC
x18 VDD VSS VSS CLK Reset net4 net5 FFD_TSPC
x19 VDD VSS VSS CLK Reset net5 net6 FFD_TSPC
x20 VDD VSS VSS CLK Reset net6 net7 FFD_TSPC
x21 VDD VSS VSS CLK Reset net7 net8 FFD_TSPC
x22 VDD VSS VSS CLK Reset net8 net9 FFD_TSPC
x23 VDD VSS VSS CLK Reset net9 net10 FFD_TSPC
x24 VDD VSS VSS CLK Reset net10 net11 FFD_TSPC
x25 VDD VSS VSS CLK Reset net11 net12 FFD_TSPC
x26 VDD VSS VSS CLK Reset net12 net14 FFD_TSPC
x28 VDD VSS VSS CLK Reset net14 EOC FFD_TSPC
.ends


* expanding   symbol:  DAC_test_ideal.sym # of pins=15
** sym_path: Func_verify/DAC_test_ideal.sym
** sch_path: Func_verify/DAC_test_ideal.sch
.subckt DAC_test_ideal Final_Out VSS Vmin D7 D3 D11 D10 D6 D2 D5 D1 D9 D0 D4 D8
*.ipin D11
*.ipin D10
*.ipin D9
*.ipin D8
*.ipin D7
*.ipin D6
*.ipin D5
*.ipin D4
*.ipin D3
*.ipin D2
*.ipin D1
*.ipin D0
*.ipin Vmin
*.ipin VSS
*.opin Final_Out
E1 net12 net1 D11 VSS 0.5
E2 net1 net2 D10 VSS 0.25
E3 net2 net3 D9 VSS 0.125
E4 net3 net4 D8 VSS 0.0625
E5 net4 net5 D7 VSS 0.03125
E6 net5 net6 D6 VSS 0.015625
E7 net6 net7 D5 VSS 7.8125e-3
E8 net7 net8 D4 VSS 3.90625e-3
E9 net8 net9 D3 VSS 1.953125e-3
E10 net9 net10 D2 VSS 9.765625e-4
E11 net10 net11 D1 VSS 4.8828125e-4
E12 net11 VSS D0 VSS 2.44140625e-4
E13 Final_Out Vmin net12 VSS {gain}
.ends


* expanding   symbol:  SAR_Register_v2.sym # of pins=27
** sym_path: Func_verify/SAR_Register_v2.sym
** sch_path: Func_verify/SAR_Register_v2.sch
.subckt SAR_Register_v2 VDD D8 D5 D11 D2 DO11 DO8 DO5 DO2 EOC D7 D1 D10 D4 DO1 DO4 DO7 DO10 D0 D3 D6
+ D9 DO0 DO3 DO6 DO9 VSS
*.ipin VDD
*.ipin VSS
*.ipin D11
*.ipin D10
*.ipin D9
*.ipin D8
*.ipin D7
*.ipin D6
*.ipin D5
*.ipin D4
*.ipin D3
*.ipin D2
*.ipin D1
*.ipin D0
*.opin DO11
*.opin DO10
*.opin DO9
*.opin DO8
*.opin DO7
*.opin DO6
*.opin DO3
*.opin DO4
*.opin DO5
*.opin DO2
*.opin DO1
*.opin DO0
*.ipin EOC
x1 DO11 D11 VDD EOC VSS FFD_logic
x2 DO10 D10 VDD EOC VSS FFD_logic
x3 DO9 D9 VDD EOC VSS FFD_logic
x4 DO8 D8 VDD EOC VSS FFD_logic
x5 DO7 D7 VDD EOC VSS FFD_logic
x6 DO6 D6 VDD EOC VSS FFD_logic
x7 DO3 D3 VDD EOC VSS FFD_logic
x8 DO4 D4 VDD EOC VSS FFD_logic
x9 DO5 D5 VDD EOC VSS FFD_logic
x10 DO2 D2 VDD EOC VSS FFD_logic
x11 DO1 D1 VDD EOC VSS FFD_logic
x12 DO0 D0 VDD EOC VSS FFD_logic
.ends


* expanding   symbol:  CAP_MIM_DAC_SplitCharge.sym # of pins=23
** sym_path: Func_verify/CAP_MIM_DAC_SplitCharge.sym
** sch_path: Func_verify/CAP_MIM_DAC_SplitCharge.sch
.subckt CAP_MIM_DAC_SplitCharge Vref_p Vin_n di0 di1 di2 VDD di3 VSS di4 out_p Vcm di5 S di6 Sb di7
+ out_n di8 di9 di10 di11 Vin_p Vref_n
*.ipin VDD
*.ipin VSS
*.ipin S
*.ipin Sb
*.ipin di3
*.ipin Vcm
*.opin out_p
*.opin out_n
*.ipin Vref_p
*.ipin Vref_n
*.ipin di0
*.ipin di1
*.ipin di2
*.ipin di5
*.ipin di4
*.ipin di7
*.ipin di6
*.ipin di9
*.ipin di8
*.ipin di11
*.ipin di10
*.ipin Vin_n
*.ipin Vin_p
x30 VDD Vref_n Vref_p VSS S Sb d11 db11 in_p_sampled net7 Network_Switch
x31 VDD Vref_n Vref_p VSS S Sb d10 db10 in_p_sampled net8 Network_Switch
x32 VDD Vref_n Vref_p VSS S Sb d9 db9 in_p_sampled net9 Network_Switch
x33 VDD Vref_n Vref_p VSS S Sb d8 db8 in_p_sampled net10 Network_Switch
x34 VDD Vref_n Vref_p VSS S Sb d7 db7 in_p_sampled net12 Network_Switch
x35 VDD Vref_n Vref_p VSS S Sb d6 db6 in_p_sampled net11 Network_Switch
x36 VDD Vref_n Vref_p VSS S Sb d5 db5 in_p_sampled net6 Network_Switch
x37 VDD Vref_n Vref_p VSS S Sb d4 db4 in_p_sampled net5 Network_Switch
x38 VDD Vref_n Vref_p VSS S Sb d3 db3 in_p_sampled net4 Network_Switch
x39 VDD Vref_n Vref_p VSS S Sb d2 db2 in_p_sampled net3 Network_Switch
x40 VDD Vref_n Vref_p VSS S Sb d1 db1 in_p_sampled net2 Network_Switch
x41 VDD Vref_n Vref_p VSS S Sb d0 db0 in_p_sampled net1 Network_Switch
x42 VDD Vref_p Vref_n VSS S Sb d11 db11 in_n_sampled net24 Network_Switch
x43 VDD Vref_p Vref_n VSS S Sb d10 db10 in_n_sampled net23 Network_Switch
x44 VDD Vref_p Vref_n VSS S Sb d9 db9 in_n_sampled net22 Network_Switch
x45 VDD Vref_p Vref_n VSS S Sb d8 db8 in_n_sampled net21 Network_Switch
x46 VDD Vref_p Vref_n VSS S Sb d7 db7 in_n_sampled net20 Network_Switch
x47 VDD Vref_p Vref_n VSS S Sb d6 db6 in_n_sampled net19 Network_Switch
x48 VDD Vref_p Vref_n VSS S Sb d5 db5 in_n_sampled net18 Network_Switch
x49 VDD Vref_p Vref_n VSS S Sb d4 db4 in_n_sampled net17 Network_Switch
x50 VDD Vref_p Vref_n VSS S Sb d3 db3 in_n_sampled net16 Network_Switch
x51 VDD Vref_p Vref_n VSS S Sb d2 db2 in_n_sampled net15 Network_Switch
x52 VDD Vref_p Vref_n VSS S Sb d1 db1 in_n_sampled net14 Network_Switch
x53 VDD Vref_p Vref_n VSS S Sb d0 db0 in_n_sampled net13 Network_Switch
x27 out_p Sb S VDD VSS out_n transmission_gate
x2 VDD di0 db0 VSS Inverter
x3 VDD db0 d0 VSS Inverter
x4 VDD di1 db1 VSS Inverter
x5 VDD db1 d1 VSS Inverter
x6 VDD di2 db2 VSS Inverter
x7 VDD db2 d2 VSS Inverter
x8 VDD di3 db3 VSS Inverter
x9 VDD db3 d3 VSS Inverter
x10 VDD di4 db4 VSS Inverter
x11 VDD db4 d4 VSS Inverter
x12 VDD di5 db5 VSS Inverter
x13 VDD db5 d5 VSS Inverter
x14 VDD di6 db6 VSS Inverter
x15 VDD db6 d6 VSS Inverter
x16 VDD di7 db7 VSS Inverter
x17 VDD db7 d7 VSS Inverter
x18 VDD di8 db8 VSS Inverter
x19 VDD db8 d8 VSS Inverter
x20 VDD di9 db9 VSS Inverter
x21 VDD db9 d9 VSS Inverter
x22 VDD di10 db10 VSS Inverter
x23 VDD db10 d10 VSS Inverter
x24 VDD di11 db11 VSS Inverter
x25 VDD db11 d11 VSS Inverter
x28 Vcm Sb S VDD VSS out_p transmission_gate
x29 Vcm Sb S VDD VSS out_n transmission_gate
x56 VDD Vref_p Vref_n VSS S Sb VSS VDD in_n_sampled net26 Network_Switch
x57 VDD Vref_n Vref_p VSS S Sb VSS VDD in_p_sampled net25 Network_Switch
XC16 net20 out_p sky130_fd_pr__cap_mim_m3_1 W=1.198 L=1.198 MF=2 m=2
XC17 net21 out_p sky130_fd_pr__cap_mim_m3_1 W=1.763 L=1.763 MF=2 m=2
XC18 net22 out_p sky130_fd_pr__cap_mim_m3_1 W=2.57 L=2.57 MF=2 m=2
XC19 net23 out_p sky130_fd_pr__cap_mim_m3_1 W=3.705 L=3.705 MF=2 m=2
XC20 net24 out_p sky130_fd_pr__cap_mim_m3_1 W=5.31 L=5.31 MF=2 m=2
x1 VDD Vin_n Sb S in_n_sampled VSS bootstrapped_switch_SH
x26 VDD Vin_p Sb S in_p_sampled VSS bootstrapped_switch_SH
x58 node_n Sb S VDD VSS node_p transmission_gate
x59 Vcm Sb S VDD VSS node_n transmission_gate
x60 Vcm Sb S VDD VSS node_p transmission_gate
XC43 net26 out_p sky130_fd_pr__cap_mim_m3_1 W=0.8 L=0.8 MF=2 m=2
XC21 net19 out_p sky130_fd_pr__cap_mim_m3_1 W=0.8 L=0.8 MF=2 m=2
XC37 out_n net12 sky130_fd_pr__cap_mim_m3_1 W=1.198 L=1.198 MF=2 m=2
XC38 out_n net10 sky130_fd_pr__cap_mim_m3_1 W=1.763 L=1.763 MF=2 m=2
XC39 out_n net9 sky130_fd_pr__cap_mim_m3_1 W=2.57 L=2.57 MF=2 m=2
XC40 out_n net8 sky130_fd_pr__cap_mim_m3_1 W=3.705 L=3.705 MF=2 m=2
XC41 out_n net7 sky130_fd_pr__cap_mim_m3_1 W=5.31 L=5.31 MF=2 m=2
XC42 out_n net25 sky130_fd_pr__cap_mim_m3_1 W=0.8 L=0.8 MF=2 m=2
XC52 out_n net11 sky130_fd_pr__cap_mim_m3_1 W=0.8 L=0.8 MF=2 m=2
XC1 net14 node_n sky130_fd_pr__cap_mim_m3_1 W=1.198 L=1.198 MF=2 m=2
XC8 net15 node_n sky130_fd_pr__cap_mim_m3_1 W=1.763 L=1.763 MF=2 m=2
XC15 net16 node_n sky130_fd_pr__cap_mim_m3_1 W=2.57 L=2.57 MF=2 m=2
XC28 net17 node_n sky130_fd_pr__cap_mim_m3_1 W=3.705 L=3.705 MF=2 m=2
XC29 net18 node_n sky130_fd_pr__cap_mim_m3_1 W=5.31 L=5.31 MF=2 m=2
XC30 net13 node_n sky130_fd_pr__cap_mim_m3_1 W=0.8 L=0.8 MF=2 m=2
XC31 node_p net2 sky130_fd_pr__cap_mim_m3_1 W=1.198 L=1.198 MF=2 m=2
XC32 node_p net3 sky130_fd_pr__cap_mim_m3_1 W=1.763 L=1.763 MF=2 m=2
XC33 node_p net4 sky130_fd_pr__cap_mim_m3_1 W=2.57 L=2.57 MF=2 m=2
XC34 node_p net27 sky130_fd_pr__cap_mim_m3_1 W=3.705 L=3.705 MF=2 m=2
XC35 node_p net28 sky130_fd_pr__cap_mim_m3_1 W=5.31 L=5.31 MF=2 m=2
XC36 node_p net1 sky130_fd_pr__cap_mim_m3_1 W=0.8 L=0.8 MF=2 m=2
XC45 node_n out_p sky130_fd_pr__cap_mim_m3_1 W=0.8 L=0.8 MF=2 m=2
XC46 node_p out_n sky130_fd_pr__cap_mim_m3_1 W=0.8 L=0.8 MF=2 m=2
.ends


* expanding   symbol:  Thesis/SAR_Logic_new.sym # of pins=18
** sym_path: Func_verify/SAR_Logic_new.sym
** sch_path: Func_verify/SAR_Logic_new.sch
.subckt SAR_Logic_new EOC clk COMP VDD VSS Reset D9 D4 D10 D5 D6 D3 D2 D1 D0 D7 D8 D11
*.ipin VDD
*.ipin VSS
*.ipin COMP
*.ipin Reset
*.ipin clk
*.opin D11
*.opin D10
*.opin D9
*.opin D8
*.opin D7
*.opin D6
*.opin D5
*.opin D4
*.opin D3
*.opin D2
*.opin D1
*.opin D0
*.opin EOC
x1 Reset VDD net1 clk VSS VSS VSS FFD_logic_RS
x2 VSS VDD net2 clk net1 VSS Reset FFD_logic_RS
x3 VSS VDD net3 clk net2 VSS Reset FFD_logic_RS
x4 VSS VDD net4 clk net3 VSS Reset FFD_logic_RS
x5 VSS VDD net5 clk net4 VSS Reset FFD_logic_RS
x6 VSS VDD net6 clk net5 VSS Reset FFD_logic_RS
x7 VSS VDD net7 clk net6 VSS Reset FFD_logic_RS
x8 VSS VDD net8 clk net7 VSS Reset FFD_logic_RS
x9 VSS VDD net9 clk net8 VSS Reset FFD_logic_RS
x10 VSS VDD net10 clk net9 VSS Reset FFD_logic_RS
x11 VSS VDD net11 clk net10 VSS Reset FFD_logic_RS
x12 VSS VDD net12 clk net11 VSS Reset FFD_logic_RS
x13 VSS VDD net13 clk net12 VSS Reset FFD_logic_RS
x14 VSS VDD EOC clk net13 VSS Reset FFD_logic_RS
x15 net2 VDD D11 D10 COMP VSS Reset FFD_logic_RS
x16 net3 VDD D10 D9 COMP VSS Reset FFD_logic_RS
x17 net4 VDD D9 D8 COMP VSS Reset FFD_logic_RS
x18 net5 VDD D8 D7 COMP VSS Reset FFD_logic_RS
x19 net6 VDD D7 D6 COMP VSS Reset FFD_logic_RS
x20 net7 VDD D6 D5 COMP VSS Reset FFD_logic_RS
x21 net8 VDD D5 D4 COMP VSS Reset FFD_logic_RS
x22 net9 VDD D4 D3 COMP VSS Reset FFD_logic_RS
x23 net10 VDD D3 D2 COMP VSS Reset FFD_logic_RS
x24 net11 VDD D2 D1 COMP VSS Reset FFD_logic_RS
x25 net12 VDD D1 D0 COMP VSS Reset FFD_logic_RS
x26 net13 VDD D0 net14 COMP VSS Reset FFD_logic_RS
x27 EOC VDD net14 VSS VSS VSS Reset FFD_logic_RS
.ends


* expanding   symbol:  Pulse_Generator.sym # of pins=9
** sym_path: Func_verify/Pulse_Generator.sym
** sch_path: Func_verify/Pulse_Generator.sch
.subckt Pulse_Generator VDD Clock clk_samp clk_sampB clk_samp_pre clk_sarB EOC clk_sar VSS
*.ipin Clock
*.ipin VDD
*.opin clk_sampB
*.opin clk_sar
*.ipin VSS
*.ipin EOC
*.opin clk_sarB
*.opin clk_samp
*.opin clk_samp_pre
x1 VDD VSS net4 Clock net1 xor
x2 VDD net3 net1 VSS Delay_cell
x3 VDD net2 net4 Clock VSS nand
x5 VDD VSS net5 net2 net6 VDD FFD_RSpin
x6 VDD net8 net5 VSS Delay_cell
x7 VSS VDD net7 clk_samp_pre VSS net6 MUX_2to1
x8 VSS VDD net9 EOC VSS net7 MUX_2to1
x9 VDD net10 net3 VSS Delay_cell
x13 VDD net9 clk_sarB VSS Inverter
x14 VDD clk_sarB clk_sar VSS Inverter
x4 VDD net2 clk_samp_pre VSS INV_PG
x15 VDD clk_samp_pre clk_sampB VSS INV_PG
x16 VDD clk_sampB clk_samp VSS INV_PG
x17 VDD net11 net10 VSS Delay_cell
x18 VDD Clock net11 VSS Delay_cell
x19 VDD clk_sar net8 VSS Delay_cell
.ends


* expanding   symbol:  FFD_TSPC.sym # of pins=7
** sym_path: Func_verify/FFD_TSPC.sym
** sch_path: Func_verify/FFD_TSPC.sch
.subckt FFD_TSPC VDD VSS SET CLOCK RESET D Q
*.ipin CLOCK
*.ipin SET
*.ipin RESET
*.ipin VDD
*.ipin VSS
*.ipin D
*.opin Q
XM1 net2 D VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 net3 CLOCK VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3 net4 Q_pre VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM4 net2 CLOCK net1 VDD sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM5 Q_pre net2 net3 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM6 QB_pre CLOCK net4 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM7 Q QB_pre VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=3 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM8 net1 D VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM9 Q_pre CLOCK VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM10 net5 Q_pre VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM11 QB_pre RS VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM12 Q QB_pre VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM13 QB_pre SET VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
x1 VDD RESET RS VSS Inverter
XM14 QB_pre SET net5 VDD sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  FFD_logic.sym # of pins=5
** sym_path: Func_verify/FFD_logic.sym
** sch_path: Func_verify/FFD_logic.sch
.subckt FFD_logic Q D VDD CLK VSS
*.ipin D
*.ipin CLK
*.ipin VDD
*.ipin VSS
*.opin Q
x1 VDD net3 D net2 VSS nand_FFD
x2 VDD net4 net2 net1 VSS nand_FFD
x3 VDD net5 net3 net6 VSS nand_FFD
x4 VDD net6 net5 net4 VSS nand_FFD
x5 VDD net8 net5 CLK VSS nand_FFD
x6 VDD net7 CLK net6 VSS nand_FFD
x7 VDD Q net8 net9 VSS nand_FFD
x8 VDD net9 Q net7 VSS nand_FFD
x9 VDD D net1 VSS Inverter
x10 VDD CLK net2 VSS Inverter
.ends


* expanding   symbol:  Network_Switch.sym # of pins=10
** sym_path: Func_verify/Network_Switch.sym
** sch_path: Func_verify/Network_Switch.sch
.subckt Network_Switch VDD ground Vref VSS S Sb d db Vin Vout
*.ipin ground
*.ipin Vref
*.ipin Vin
*.opin Vout
*.ipin VDD
*.ipin VSS
*.ipin S
*.ipin Sb
*.ipin d
*.ipin db
x1 ground d db VDD VSS net1 transmission_gate
x2 Vref db d VDD VSS net1 transmission_gate
x3 net1 S Sb VDD VSS Vout transmission_gate
x4 Vin Sb S VDD VSS Vout transmission_gate
.ends


* expanding   symbol:  bootstrapped_switch.sym # of pins=6
** sym_path: Func_verify/bootstrapped_switch.sym
** sch_path: Func_verify/bootstrapped_switch.sch
.subckt bootstrapped_switch VDD in clkb clk out VSS
*.ipin in
*.opin out
*.ipin VSS
*.ipin VDD
*.ipin clkb
*.ipin clk
XM1 net4 clkb net5 net5 sky130_fd_pr__nfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 in Vg net4 VSS sky130_fd_pr__nfet_01v8 L=1 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3 Vp Vg net1 Vp sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM5 out Vg in VSS sky130_fd_pr__nfet_01v8 L=0.15 W=30 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM6 out clkb in VDD sky130_fd_pr__pfet_01v8 L=0.15 W=30 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM8 net6 clkb net2 net2 sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XC1 net4 Vp sky130_fd_pr__cap_mim_m3_1 W=18 L=18 MF=10 m=10
XM7 Vg VDD net6 net6 sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM4 Vg net3 Vp Vp sky130_fd_pr__pfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XC2 out VSS sky130_fd_pr__cap_mim_m3_1 W=36 L=36 MF=20 m=20
XM10 net1 clk net7 net1 sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM11 net5 clkb net8 net8 sky130_fd_pr__nfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM12 net7 clk VDD net7 sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM13 net8 clkb VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM14 net2 clkb VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM15 net3 clk VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM16 net3 clk net4 VSS sky130_fd_pr__nfet_01v8 L=1 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM17 net3 Vg net4 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  transmission_gate.sym # of pins=6
** sym_path: Func_verify/transmission_gate.sym
** sch_path: Func_verify/transmission_gate.sch
.subckt transmission_gate in clkb clk VDD VSS out
*.ipin in
*.ipin clk
*.ipin clkb
*.opin out
*.ipin VDD
*.ipin VSS
XM1 out clk in VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 out clkb in VDD sky130_fd_pr__pfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  Inverter.sym # of pins=4
** sym_path: Func_verify/Inverter.sym
** sch_path: Func_verify/Inverter.sch
.subckt Inverter VDD IN OUT VSS
*.ipin IN
*.ipin VSS
*.ipin VDD
*.opin OUT
XM1 OUT IN VSS VSS sky130_fd_pr__nfet_01v8 L=0.3 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 OUT IN VDD VDD sky130_fd_pr__pfet_01v8 L=0.3 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  bootstrapped_switch_SH.sym # of pins=6
** sym_path: Func_verify/bootstrapped_switch_SH.sym
** sch_path: Func_verify/bootstrapped_switch_SH.sch
.subckt bootstrapped_switch_SH VDD in clkb clk out VSS
*.ipin in
*.opin out
*.ipin VSS
*.ipin VDD
*.ipin clkb
*.ipin clk
XM1 net3 clkb net4 net4 sky130_fd_pr__nfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 in Vg net3 VSS sky130_fd_pr__nfet_01v8 L=1 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3 Vp Vg net1 Vp sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM5 out Vg in VSS sky130_fd_pr__nfet_01v8 L=0.15 W=30 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM6 out clkb in VDD sky130_fd_pr__pfet_01v8 L=0.15 W=30 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM8 net5 clkb net2 net2 sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XCb net3 Vp sky130_fd_pr__cap_mim_m3_1 W=18 L=18 MF=10 m=10
XM7 Vg VDD net5 net5 sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM4 Vg clkb Vp Vp sky130_fd_pr__pfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM10 net1 clk net6 net1 sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM11 net4 clkb net7 net7 sky130_fd_pr__nfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM12 net6 clk VDD net6 sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM13 net7 clkb VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM14 net2 clkb VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XC2 out VSS sky130_fd_pr__cap_mim_m3_1 W=36 L=36 MF=20 m=20
.ends


* expanding   symbol:  Thesis/FFD_logic_RS.sym # of pins=7
** sym_path: Func_verify/FFD_logic_RS.sym
** sch_path: Func_verify/FFD_logic_RS.sch
.subckt FFD_logic_RS Set VDD Q CLK D VSS Reset
*.ipin D
*.ipin CLK
*.ipin VDD
*.ipin VSS
*.opin Q
*.ipin Set
*.ipin Reset
x1 VDD net3 D net2 VSS nand_FFD
x2 VDD net4 net2 net1 VSS nand_FFD
x5 VDD net8 net5 CLK VSS nand_FFD
x6 VDD net7 CLK net6 VSS nand_FFD
x9 VDD D net1 VSS Inverter
x10 VDD CLK net2 VSS Inverter
x3 net6 VDD net5 net10 net3 VSS nand_FFD_3pin
x4 net11 VDD net6 net5 net4 VSS nand_FFD_3pin
x7 net9 VDD Q net10 net8 VSS nand_FFD_3pin
x8 net11 VDD net9 Q net7 VSS nand_FFD_3pin
x11 VDD Set net10 VSS Inverter
x12 VDD Reset net11 VSS Inverter
.ends


* expanding   symbol:  xor.sym # of pins=5
** sym_path: Func_verify/xor.sym
** sch_path: Func_verify/xor.sch
.subckt xor VDD VSS Y A B
*.ipin A
*.ipin VDD
*.opin Y
*.ipin B
*.ipin VSS
XM1 net1 A VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 Y A_bar net1 VDD sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3 net1 B VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM4 Y B_bar net1 VDD sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM5 Y A net2 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM6 net2 B VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM7 Y A_bar net3 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM8 net3 B_bar VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM9 A_bar A VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM10 A_bar A VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM11 B_bar B VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM12 B_bar B VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  Delay_cell.sym # of pins=4
** sym_path: Func_verify/Delay_cell.sym
** sch_path: Func_verify/Delay_cell.sch
.subckt Delay_cell VDD IN OUT VSS
*.ipin IN
*.ipin VSS
*.ipin VDD
*.opin OUT
XM3 net1 IN VSS VSS sky130_fd_pr__nfet_01v8 L=0.3 W=6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM4 net1 IN VDD VDD sky130_fd_pr__pfet_01v8 L=0.3 W=12 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM5 net2 net1 VSS VSS sky130_fd_pr__nfet_01v8 L=0.3 W=6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM6 net2 net1 VDD VDD sky130_fd_pr__pfet_01v8 L=0.3 W=12 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM7 net3 net2 VSS VSS sky130_fd_pr__nfet_01v8 L=0.3 W=6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM8 net3 net2 VDD VDD sky130_fd_pr__pfet_01v8 L=0.3 W=12 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM9 OUT net3 VSS VSS sky130_fd_pr__nfet_01v8 L=0.3 W=6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM10 OUT net3 VDD VDD sky130_fd_pr__pfet_01v8 L=0.3 W=12 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XC1 net1 VSS sky130_fd_pr__cap_mim_m3_1 W=9.8 L=9.8 MF=4 m=4
XC2 net2 VSS sky130_fd_pr__cap_mim_m3_1 W=9.8 L=9.8 MF=4 m=4
XC3 net3 VSS sky130_fd_pr__cap_mim_m3_1 W=9.8 L=9.8 MF=4 m=4
.ends


* expanding   symbol:  nand.sym # of pins=5
** sym_path: Func_verify/nand.sym
** sch_path: Func_verify/nand.sch
.subckt nand VDD Y A B VSS
*.ipin VDD
*.ipin A
*.ipin B
*.ipin VSS
*.opin Y
XM1 Y A net1 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 net1 B VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3 Y A VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM4 Y B VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  FFD_RSpin.sym # of pins=6
** sym_path: Func_verify/FFD_RSpin.sym
** sch_path: Func_verify/FFD_RSpin.sch
.subckt FFD_RSpin VDD VSS RESET CLOCK Q D
*.ipin CLOCK
*.ipin D
*.ipin RESET
*.ipin VDD
*.ipin VSS
*.opin Q
XM1 D CLKB net1 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 D CLK net1 VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3 net2 CLK net3 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM4 net2 CLKB net3 VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM5 net1 CLK net5 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM6 net1 CLKB net5 VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM7 net3 CLKB net6 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM8 net3 CLK net6 VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
x2 VDD RESET net3 net4 VSS nor_FFD
x3 VDD RESET net1 net2 VSS nor_FFD
x7 VDD CLOCK CLKB VSS Inverter
x8 VDD CLKB CLK VSS Inverter
x1 VDD net4 net7 VSS Inverter
x4 VDD net7 Q VSS Inverter
x5 VDD net2 net5 VSS Inverter
x6 VDD net4 net6 VSS Inverter
.ends


* expanding   symbol:  MUX_2to1.sym # of pins=6
** sym_path: Func_verify/MUX_2to1.sym
** sch_path: Func_verify/MUX_2to1.sch
.subckt MUX_2to1 in1 VDD out select VSS in0
*.ipin select
*.ipin VSS
*.ipin VDD
*.ipin in1
*.ipin in0
*.opin out
XM1 net1 select VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 net1 select VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3 out select in1 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=3 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM4 out net1 in1 VDD sky130_fd_pr__pfet_01v8 L=0.15 W=3 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM5 out net1 in0 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=3 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM6 out select in0 VDD sky130_fd_pr__pfet_01v8 L=0.15 W=3 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  INV_PG.sym # of pins=4
** sym_path: Func_verify/INV_PG.sym
** sch_path: Func_verify/INV_PG.sch
.subckt INV_PG VDD IN OUT VSS
*.ipin IN
*.ipin VSS
*.ipin VDD
*.opin OUT
XM1 OUT IN VSS VSS sky130_fd_pr__nfet_01v8 L=0.3 W=5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 OUT IN VDD VDD sky130_fd_pr__pfet_01v8 L=0.3 W=8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  nand_FFD.sym # of pins=5
** sym_path: Func_verify/nand_FFD.sym
** sch_path: Func_verify/nand_FFD.sch
.subckt nand_FFD VDD Y A B VSS
*.ipin VDD
*.ipin A
*.ipin B
*.ipin VSS
*.opin Y
XM1 Y A net1 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 net1 B VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3 Y A VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM4 Y B VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  Thesis/nand_FFD_3pin.sym # of pins=6
** sym_path: Func_verify/nand_FFD_3pin.sym
** sch_path: Func_verify/nand_FFD_3pin.sch
.subckt nand_FFD_3pin C VDD Y A B VSS
*.ipin VDD
*.ipin A
*.ipin B
*.ipin VSS
*.opin Y
*.ipin C
XM1 Y A net1 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 net1 B net2 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3 Y A VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM4 Y B VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM5 Y C VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM6 net2 C VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  nor_FFD.sym # of pins=5
** sym_path: Func_verify/nor_FFD.sym
** sch_path: Func_verify/nor_FFD.sch
.subckt nor_FFD VDD A B Y VSS
*.ipin VDD
*.ipin A
*.ipin B
*.ipin VSS
*.opin Y
XM1 Y A VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 Y B VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3 net1 A VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=2.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM4 Y B net1 VDD sky130_fd_pr__pfet_01v8 L=0.15 W=2.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends

.GLOBAL GND
.end
